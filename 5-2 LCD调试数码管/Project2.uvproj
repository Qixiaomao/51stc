# Keil uVision project Project2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.h Delay.h
    G:/Pes21/课件及程序源码/程序源码/程序源码/LCD1602驱动代码/: LCD1602.c
